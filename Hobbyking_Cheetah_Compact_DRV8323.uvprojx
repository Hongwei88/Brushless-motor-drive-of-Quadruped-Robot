# Keil uVision project Hobbyking_Cheetah_Compact_DRV8323.uvprojx, settings and files
target Hobbyking_Cheetah_Compact_DRV8323 (ARM-ADS)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: Hobbyking_Cheetah_Compact_DRV8323 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEVICE_RTC=1,DEVICE_SLEEP=1,ARM_MATH_CM4,MBED_BUILD_TIMESTAMP=1567486712.43,TARGET_STM32F4,__ASSERT_MSG,TARGET_NAME=NUCLEO_F446RE,TARGET_RELEASE,TARGET_STM32F446xE,DEVICE_PORTINOUT=1,TARGET_FF_MORPHO,DEVICE_I2C_ASYNCH=1,TARGET_FF_ARDUINO,TARGET_RTOS_M4_M7,DEVICE_CAN=1,DEVICE_PORTOUT=1,DEVICE_FLASH=1,DEVICE_STDIO_MESSAGES=1,DEVICE_ANALOGOUT=1,TARGET_LIKE_MBED,DEVICE_SERIAL_FC=1,DEVICE_SERIAL=1,DEVICE_ANALOGIN=1,TARGET_LIKE_CORTEX_M4,TARGET_CORTEX_M,TARGET_NUCLEO_F446RE,USB_STM_HAL,TARGET_STM32F446RE,DEVICE_I2C=1,__CORTEX_M4,TARGET_CORTEX,DEVICE_LOWPOWERTIMER=1,TARGET_STM,TOOLCHAIN_ARM,DEVICE_INTERRUPTIN=1,TOOLCHAIN_ARM_STD,__CMSIS_RTOS,DEVICE_PWMOUT=1,DEVICE_SERIAL_ASYNCH=1,TARGET_FAMILY_STM32,DEVICE_SPI=1,__MBED__=1,DEVICE_SPISLAVE=1,DEVICE_PORTIN=1,TARGET_M4,__FPU_PRESENT=1,DEVICE_I2CSLAVE=1,USBHOST_OTHER,DEVICE_SPI_ASYNCH=1,TRANSACTION_QUEUE_SIZE_SPI=2,__MBED_CMSIS_RTOS_CM
  c misc: --no_rtti --split_sections -c --apcs=interwork --no_depend_system_headers --md --gnu --cpu=Cortex-M4.fp.sp --preinclude=mbed_config.h
  c include: ..\Hobbyking_Cheetah_Compact_DRV8323;.\Calibration;.\CAN;.\Config;.\DRV8323;.\FastMath;.\FastPWM;.\FlashWriter;.\FOC;.\PositionSensor;.\PreferenceWriter;.\Tables;.\mbed-dev;.\mbed-dev\cmsis;.\mbed-dev\cmsis\TARGET_CORTEX_M;.\mbed-dev\cmsis\TARGET_CORTEX_M\TOOLCHAIN_ARM;.\mbed-dev\drivers;.\mbed-dev\hal;.\mbed-dev\hal\storage_abstraction;.\mbed-dev\platform;.\mbed-dev\targets;.\mbed-dev\targets\TARGET_STM;.\mbed-dev\targets\TARGET_STM\TARGET_STM32F4;.\mbed-dev\targets\TARGET_STM\TARGET_STM32F4\TARGET_STM32F446xE;.\mbed-dev\targets\TARGET_STM\TARGET_STM32F4\TARGET_STM32F446xE\TARGET_NUCLEO_F446RE;.\mbed-dev\targets\TARGET_STM\TARGET_STM32F4\TARGET_STM32F446xE\device;.\mbed-dev\targets\TARGET_STM\TARGET_STM32F4\device
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M4,-DUSB_STM_HAL,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-DUSBHOST_OTHER,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed-dev/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/device/TOOLCHAIN_ARM_STD/stm32f446xx.sct
  link misc: --show_full_path --keep=os_cb_sections
  group Hobbyking_Cheetah_Compact_DRV8323
    ./: hw_setup.cpp main.cpp math_ops.cpp
  group Calibration
    Calibration/: calibration.cpp
  group CAN
    CAN/: CAN_com.cpp
  group DRV8323
    DRV8323/: DRV.cpp
  group FastMath
    ./FastMath/: FastMath.cpp
  group FastPWM
    ./: FastPWM.lib
  group FlashWriter
    FlashWriter/: FlashWriter.cpp stm32f4xx_flash.c
  group FOC
    FOC/: foc.cpp
  group PositionSensor
    PositionSensor/: PositionSensor.cpp
  group PreferenceWriter
    PreferenceWriter/: PrefrenceWriter.cpp
  group mbed-dev
    mbed-dev/drivers/: AnalogIn.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp Ethernet.cpp FlashIAP.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp RawSerial.cpp Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp UARTSerial.cpp
    mbed-dev/targets/TARGET_STM/TARGET_STM32F4/: analogin_api.c analogout_device.c flash_api.c gpio_irq_device.c pwmout_device.c serial_device.c spi_api.c
    mbed-dev/targets/TARGET_STM/: analogout_api.c can_api.c gpio_api.c gpio_irq_api.c hal_tick_16b.c hal_tick_32b.c i2c_api.c lp_ticker.c mbed_overrides.c pinmap.c port_api.c pwmout_api.c serial_api.c sleep.c us_ticker_16b.c us_ticker_32b.c
    mbed-dev/platform/: ATCmdParser.cpp CallChain.cpp FileBase.cpp FileHandle.cpp FilePath.cpp FileSystemHandle.cpp LocalFileSystem.cpp mbed_alloc_wrappers.cpp mbed_application.c mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_interface.c mbed_mem_trace.c mbed_mktime.c mbed_poll.cpp mbed_rtc_time.cpp mbed_sdk_boot.c mbed_semihost_api.c mbed_stats.c mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp Stream.cpp
    mbed-dev/targets/TARGET_STM/TARGET_STM32F4/device/: hal_init_pre.c stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
    mbed-dev/hal/: mbed_flash_api.c mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_sleep_manager.c mbed_ticker_api.c mbed_us_ticker_api.c
    mbed-dev/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/TARGET_NUCLEO_F446RE/: PeripheralPins.c
    ./mbed-dev/targets/TARGET_STM/TARGET_STM32F4/device/: stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c system_stm32f4xx.c
    ./mbed-dev/targets/TARGET_STM/: rtc_api.c stm_spi_api.c
    ./mbed-dev/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/TARGET_NUCLEO_F446RE/: system_clock.c
    ./mbed-dev/targets/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/device/TOOLCHAIN_ARM_STD/: startup_stm32f446xx.s
    ./mbed-dev/platform/: mbed_retarget.cpp
